# Keil uVision project STM32F030Demo.uvprojx, settings and files
target Stm32f030demo (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030Demo
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\HARDWARE;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;..\User;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c exti.c exti.h pwm.c pwm.h bsp_adc.c bsp_adc.h key.c key.h
    ../STM32F03x_FWLib/src/: stm32f0xx_misc.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group HARDWARE
    ../HARDWARE/: USART1.c USART1_API.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_adc.c stm32f0xx_dma.c
    ../STM32F03x_FWLib/inc/: stm32f0xx_exti.h stm32f0xx_tim.h
